#include <iostream>
using namespace std;
int main()
{
	int a,b,c,d,e,f,avg,add,mult,mod,sub,max,mini;
	cout<<"enter 5 numbers";
	cin>>a>>b>>c>>d>>e;
	add=a+b+c+d+e;
	mult=a*b*c*d*e;
	avg=(a+b+c+d+e)/5;
	mod=(((a%b)%c)%d)%e;
	sub=a-b-c-d-e;
	cout<<"the sum is:"<<add;
	cout<<"the product is:"<<mult;
	cout<<"the avg is:"<<avg;
	cout<<"the mod is:"<<mod;
	cout<<"the diff. is:"<<sub;
	max=0;
	if(a>max)
	max=a;
	if(b>max)
	max=b;
	if(c>max)
	max=c;
	if(d>max )
	max=d;
	if(e>max )
	max=e;
	mini=max;
	if(a<mini)
	mini=a;
	if(b<mini)
	mini=b;
	if(c<mini)
	mini=c;
	if(d<mini )
	mini=d;
	if(e<mini )
	mini=e;
	cout<<"Max:"<<max<<endl;
	cout<<"Min:"<<mini<<endl;
	
}





























































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































































