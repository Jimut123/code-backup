#include<stdio.h>
void main()
{
int m,i,j,k,c,d,p,max,f,a[100][100],v=-1;
clrscr();
printf("Enter the value of one row :");
scanf("%d",&m);
for(i=0;i<m;i++)
{
for(j=0;j<m;j++)
{
scanf("%d",&a[i][j]);
}
}
for(i=0;i<m;)
{
v++;
c=0;
d=0;
if(a[i][j]!=-1)
{
for(j=0;j<m;j++)
{
c=c+a[i][j];
}
max=c;
for(k=i+1;k<m;k++)
{
d=0;
for(p=0;p<m;p++)
{
d=d+a[k][p];
}
if(d>max)
{
max=d;
f=k;
}
}
if(f<=v)
i++;
for(j=0;j<m;j++)
{
if(a[f][j]!=-1)
printf("%d\t",a[f][j]);
a[f][j]=-1;
}
printf("\n");
}
}
//printf("\n");
for(i=0;i<m;i++)
{
for(j=0;j<m;j++)
{
if(a[i][j]!=-1)
printf("%d\t",a[i][j]);
}
//printf("\n");
}
getch();
}