#include<stdio.h>
#include<zarvis.h>
void main()
{
int i,n,j,a[10][10],k,h,s[100],u,v,t,c1=0,p,q=0;
clrscr();
printf("Enter the size of 1 side ::\n");
scanf("%d",&n);
for(i=0;i<n;i++)
{
for(j=0;j<n;j++)
{
printf("Enter the element of %d th row and %d th column :: \n",i+1,j+1);
scanf("%d",&a[i][j]);
}
}
printf("\n");
for(i=n-1;i>=0;i--)
{
//l1++;
for(j=n-1;j>=0;j--)
{
//l2++;
printf("\nWnat to pop or push ?(1/2)\n and 4 to exit\n");
scanf("%d",&p);
if(p==4)
exit(3);
if(p==1)
{
q++;
//printf("%d\t",a[i][j]);
for(u=0;u<n;u++)
{
for(v=0;v<n;v++)
{
if(u+v<q)
{
s[c1++]=a[u][v];
printf("**%d\n",a[u][v]);
}
if(v<n-1)
{
t=a[u][v+1];
a[u][v]=t;
//s[c1]=a[u][v];
}
if(v==n-1)
{
t=a[u+1][0];
a[u][v]=t;
//s[c1]=a[u][v];
}
}
//printf("%d\t",s[c1]);
//c1++;
/*if(p==2)
{
s[c++]=a[i][j];
//printf("%d\t",a[i][j]);
for(u=0;u<n;u++)
{
for(v=0;v<n;v++)
{
if(v<n-1)
{
t=a[u][v+1];
a[u][v]=t;
}
if(v==n-1)
{
t=a[u+1][0];
a[u][v]=t;
}
}  */
}
}
a[i][j]=0;
for(k=0;k<n;k++)
{
for(h=0;h<n;h++)
{
printf("%d\t",a[k][h]);
delay();
}
printf("\n\n");
}
/*printf("\t\t\t\n Stack = \n");
for(v=0;v<c;v++)
printf("\n %d",s[v]); */
}
printf("\n");
}
getch();
}