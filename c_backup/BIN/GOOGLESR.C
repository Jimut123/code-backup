#include<stdio.h>
#define NOW 14
void main()
{
int i,l,c=0,j,a[12],max,k=0,len[12],dif[12],min,d[12],v=1,t,t1[12],t2[12],t3[12];
int t0[12],t5,t20[12],m;
char s[100],p1[20],p2[20],p3[20],p4[20],p5[20];
char q[100][100]={{"Christmas"},
	    {"Amlyan"},
	    {"Jimut"},
	    {"Simut"},
	    {"Sachin"},
	    {"Rounak"},
	    {"google"},
	    {"facebook"},
	    {"twitter"},
	    {"instagram"},
	    {"whatsapp"},
	    {"zebra"},
	    {"Aditya"},
	    {"cab"},
	    };
clrscr();
printf("List of words :: \n");
for(i=0;i<NOW;i++)
{
k=0;
for(j=0;q[i][j]!='\0';j++)
{
printf("%c",q[i][j]);
k++;
}
len[i]=k;
printf("\n");
}
printf("\nEnter a word of your choice ::");
gets(s);
l=strlen(s);
for(i=0;i<NOW;i++)
{
c=0;
for(j=0;q[i][j]!='\0';j++)
{
if(q[i][j]==s[j] || q[i][j]-s[j]==32 ||s[j]-q[i][j]==32)
{
c++;
}
}
a[i]=c;
}
max=a[0];
for(i=0;i<NOW;i++)
{
if(a[i]>max)
{
max=a[i];
j=i;
}
}
printf("\nFrom the first perspective, your word should be ::");
puts(q[j]);
k=0;
for(i=0;i<NOW;i++)
{
if(l>len[i])
dif[i]=l-len[i];
else if(len[i]>l)
dif[i]=len[i]-l;
else
dif[i]=0;
}
min=dif[0];
k=-1;
for(i=0;i<NOW;i++)
{
if(min>dif[i])
{
min=dif[i];
}
}
k=-1;
for(i=0;i<NOW;i++)
{
v=1;
if(min==dif[i])
{
j=i;
k++;
v=0;
}
if(k>=0&&v==0)
{
d[k]=j;
}
v=1;
}
printf("\nFrom the Second perspective, your word should be ::");
for(i=0;i<=k;i++)
{
puts(q[d[i]]);
}

k=0;
v=0;
t5=0;
for(i=0;i<NOW;i++)
{
t5=0;
k=0;
for(j=0;q[i][j]!='\0';j++)
{
if(q[i][j]==s[k]||q[i][j]-s[k]==32||s[k]-q[i][j]==32)
{
for(t=0;t<strlen(s);t++)	    //****
{
if(s[t]!=q[i][j]&&q[i][j]-s[t]!=32&&s[t]-q[i][j]!=32)
{
t5=0;
j++;
break;
}
else
{
t5=5;
j++;
}
}
if(t5==0)
break;
}
}
if(t5==5)
t0[v++]=i;
}
printf("From the 3rd perspective we get ::");
for(i=0;i<v;i++)
puts(q[t0[i]]);
k=0;
v=0;
for(i=0;i<NOW;i++)
{
k=0;
m=0;
for(j=0;q[i][j]!='\0';j++)
{

if(q[i][j]==s[m]||q[i][j]-s[m]==32||s[m]-q[i][j]==32)
{
m++;
}
}
t2[i]=m;
v++;
}
max=t2[0];
for(i=0;i<v;i++)
{
if(t2[i]>max)
{
max=t2[i];
k=i;
}
}
printf("From the 4rth perspective we get ::");
puts(q[k]);
k=0;
v=0;
for(i=0;i<NOW;i++)
{
k=0;
m=0;
for(j=0;s[j]!='\0';j++)
{
if(q[i][m]==s[j]||q[i][m]-s[j]==32||s[j]-q[i][m]==32)
{
m++;
}
}
t2[i]=m;
v++;
}
max=t2[0];
for(i=0;i<v;i++)
{
if(t2[i]>max)
{
max=t2[i];
k=i;
}
}
printf("From the 5th perspective we get ::");
puts(q[k]);
getch();
}